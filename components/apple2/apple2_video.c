#include "apple2/apple2_video.h"

#include "apple2/apple2_machine.h"

#include <string.h>

static const uint16_t s_palette_rgb565[16] = {
    0x0000, 0xB004, 0x0016, 0x783E, 0x02E0, 0x5AEB, 0x05FF, 0x7DFF,
    0xA145, 0xFD20, 0xAD55, 0xFD9F, 0x07E0, 0xFFE0, 0x87FF, 0xFFFF,
};

static const uint8_t s_ascii_font[96][8] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08,0x00,0x08,0x00},
    {0x14,0x14,0x14,0x00,0x00,0x00,0x00,0x00}, {0x14,0x14,0x3E,0x14,0x3E,0x14,0x14,0x00},
    {0x08,0x1E,0x28,0x1C,0x0A,0x3C,0x08,0x00}, {0x30,0x32,0x04,0x08,0x10,0x26,0x06,0x00},
    {0x18,0x24,0x28,0x10,0x2A,0x24,0x1A,0x00}, {0x0C,0x08,0x10,0x00,0x00,0x00,0x00,0x00},
    {0x04,0x08,0x10,0x10,0x10,0x08,0x04,0x00}, {0x10,0x08,0x04,0x04,0x04,0x08,0x10,0x00},
    {0x00,0x08,0x2A,0x1C,0x2A,0x08,0x00,0x00}, {0x00,0x08,0x08,0x3E,0x08,0x08,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x0C,0x08,0x10,0x00}, {0x00,0x00,0x00,0x3E,0x00,0x00,0x00,0x00},
    {0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00}, {0x02,0x04,0x08,0x10,0x20,0x00,0x00,0x00},
    {0x1C,0x22,0x26,0x2A,0x32,0x22,0x1C,0x00}, {0x08,0x18,0x08,0x08,0x08,0x08,0x1C,0x00},
    {0x1C,0x22,0x02,0x0C,0x10,0x20,0x3E,0x00}, {0x1C,0x22,0x02,0x0C,0x02,0x22,0x1C,0x00},
    {0x04,0x0C,0x14,0x24,0x3E,0x04,0x04,0x00}, {0x3E,0x20,0x3C,0x02,0x02,0x22,0x1C,0x00},
    {0x0E,0x10,0x20,0x3C,0x22,0x22,0x1C,0x00}, {0x3E,0x22,0x04,0x08,0x08,0x08,0x08,0x00},
    {0x1C,0x22,0x22,0x1C,0x22,0x22,0x1C,0x00}, {0x1C,0x22,0x22,0x1E,0x02,0x04,0x38,0x00},
    {0x00,0x18,0x18,0x00,0x18,0x18,0x00,0x00}, {0x00,0x18,0x18,0x00,0x18,0x10,0x20,0x00},
    {0x06,0x08,0x10,0x20,0x10,0x08,0x06,0x00}, {0x00,0x00,0x3E,0x00,0x3E,0x00,0x00,0x00},
    {0x30,0x08,0x04,0x02,0x04,0x08,0x30,0x00}, {0x1C,0x22,0x02,0x0C,0x08,0x00,0x08,0x00},
    {0x1C,0x22,0x2E,0x2A,0x2E,0x20,0x1E,0x00}, {0x1C,0x22,0x22,0x3E,0x22,0x22,0x22,0x00},
    {0x3C,0x22,0x22,0x3C,0x22,0x22,0x3C,0x00}, {0x1C,0x22,0x20,0x20,0x20,0x22,0x1C,0x00},
    {0x38,0x24,0x22,0x22,0x22,0x24,0x38,0x00}, {0x3E,0x20,0x20,0x3C,0x20,0x20,0x3E,0x00},
    {0x3E,0x20,0x20,0x3C,0x20,0x20,0x20,0x00}, {0x1C,0x22,0x20,0x20,0x26,0x22,0x1E,0x00},
    {0x22,0x22,0x22,0x3E,0x22,0x22,0x22,0x00}, {0x1C,0x08,0x08,0x08,0x08,0x08,0x1C,0x00},
    {0x0E,0x04,0x04,0x04,0x04,0x24,0x18,0x00}, {0x22,0x24,0x28,0x30,0x28,0x24,0x22,0x00},
    {0x20,0x20,0x20,0x20,0x20,0x20,0x3E,0x00}, {0x22,0x36,0x2A,0x2A,0x22,0x22,0x22,0x00},
    {0x22,0x22,0x32,0x2A,0x26,0x22,0x22,0x00}, {0x1C,0x22,0x22,0x22,0x22,0x22,0x1C,0x00},
    {0x3C,0x22,0x22,0x3C,0x20,0x20,0x20,0x00}, {0x1C,0x22,0x22,0x22,0x2A,0x24,0x1A,0x00},
    {0x3C,0x22,0x22,0x3C,0x28,0x24,0x22,0x00}, {0x1C,0x22,0x20,0x1C,0x02,0x22,0x1C,0x00},
    {0x3E,0x08,0x08,0x08,0x08,0x08,0x08,0x00}, {0x22,0x22,0x22,0x22,0x22,0x22,0x1C,0x00},
    {0x22,0x22,0x22,0x22,0x22,0x14,0x08,0x00}, {0x22,0x22,0x22,0x2A,0x2A,0x36,0x22,0x00},
    {0x22,0x22,0x14,0x08,0x14,0x22,0x22,0x00}, {0x22,0x22,0x14,0x08,0x08,0x08,0x08,0x00},
    {0x3E,0x02,0x04,0x08,0x10,0x20,0x3E,0x00}, {0x1C,0x10,0x10,0x10,0x10,0x10,0x1C,0x00},
    {0x20,0x10,0x08,0x04,0x02,0x00,0x00,0x00}, {0x1C,0x04,0x04,0x04,0x04,0x04,0x1C,0x00},
    {0x08,0x14,0x22,0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x00,0x00,0x00,0x00,0x3E,0x00},
    {0x10,0x08,0x04,0x00,0x00,0x00,0x00,0x00}, {0x00,0x1C,0x02,0x1E,0x22,0x22,0x1E,0x00},
    {0x20,0x20,0x20,0x3C,0x22,0x22,0x3C,0x00}, {0x00,0x1C,0x22,0x20,0x20,0x22,0x1C,0x00},
    {0x02,0x02,0x02,0x1E,0x22,0x22,0x1E,0x00}, {0x00,0x1C,0x22,0x3E,0x20,0x22,0x1C,0x00},
    {0x0E,0x10,0x10,0x3C,0x10,0x10,0x10,0x00}, {0x00,0x1E,0x22,0x22,0x1E,0x02,0x1C,0x00},
    {0x20,0x20,0x20,0x3C,0x22,0x22,0x22,0x00}, {0x08,0x00,0x18,0x08,0x08,0x08,0x1C,0x00},
    {0x04,0x00,0x0C,0x04,0x04,0x24,0x18,0x00}, {0x20,0x20,0x24,0x28,0x30,0x28,0x24,0x00},
    {0x18,0x08,0x08,0x08,0x08,0x08,0x1C,0x00}, {0x00,0x36,0x2A,0x2A,0x2A,0x2A,0x22,0x00},
    {0x00,0x3C,0x22,0x22,0x22,0x22,0x22,0x00}, {0x00,0x1C,0x22,0x22,0x22,0x22,0x1C,0x00},
    {0x00,0x3C,0x22,0x22,0x3C,0x20,0x20,0x00}, {0x00,0x1E,0x22,0x22,0x1E,0x02,0x02,0x00},
    {0x00,0x2C,0x32,0x20,0x20,0x20,0x20,0x00}, {0x00,0x1E,0x20,0x1C,0x02,0x22,0x1C,0x00},
    {0x10,0x10,0x3C,0x10,0x10,0x12,0x0C,0x00}, {0x00,0x22,0x22,0x22,0x22,0x22,0x1E,0x00},
    {0x00,0x22,0x22,0x22,0x22,0x14,0x08,0x00}, {0x00,0x22,0x22,0x2A,0x2A,0x36,0x22,0x00},
    {0x00,0x22,0x14,0x08,0x14,0x22,0x22,0x00}, {0x00,0x22,0x22,0x22,0x1E,0x02,0x1C,0x00},
    {0x00,0x3E,0x04,0x08,0x10,0x20,0x3E,0x00}, {0x0C,0x10,0x10,0x20,0x10,0x10,0x0C,0x00},
    {0x08,0x08,0x08,0x00,0x08,0x08,0x08,0x00}, {0x30,0x08,0x08,0x04,0x08,0x08,0x30,0x00},
    {0x10,0x2A,0x04,0x00,0x00,0x00,0x00,0x00}, {0x7F,0x41,0x5D,0x55,0x5D,0x41,0x7F,0x00},
};

uint16_t apple2_text_row_address(bool page2, uint8_t row)
{
    const uint16_t base = page2 ? 0x0800U : 0x0400U;
    return (uint16_t)(base + ((row & 0x07U) << 7) + ((row >> 3) * 0x28U));
}

uint16_t apple2_hires_line_address(bool page2, uint8_t line)
{
    const uint16_t base = page2 ? 0x4000U : 0x2000U;
    return (uint16_t)(base +
                      ((line & 0x07U) << 10) +
                      (((line >> 3) & 0x07U) << 7) +
                      ((line >> 6) * 0x28U));
}

uint16_t apple2_palette_rgb565(uint8_t color_index)
{
    return s_palette_rgb565[color_index & 0x0FU];
}

const uint8_t *apple2_ascii_font(uint8_t ascii)
{
    if (ascii < 32U || ascii > 127U) {
        ascii = '?';
    }
    return s_ascii_font[ascii - 32U];
}

bool apple2_text_code_is_flashing(uint8_t code)
{
    return (code & 0xC0U) == 0x40U;
}

bool apple2_text_code_is_flash_space(uint8_t code)
{
    return apple2_text_code_is_flashing(code) && (code & 0x3FU) == 0x20U;
}

uint8_t apple2_text_code_to_ascii(uint8_t code, bool *inverse)
{
    const uint8_t glyph_index = (uint8_t)(code & 0x3FU);
    uint8_t ascii;

    if ((code & 0x80U) != 0U) {
        *inverse = false;
    } else if ((code & 0x40U) != 0U) {
        *inverse = false;
    } else {
        *inverse = true;
    }
    ascii = (glyph_index < 32U) ? (uint8_t)(glyph_index + 64U) : glyph_index;

    return ascii;
}

static void apple2_render_text_row(const uint8_t *memory, const apple2_video_state_t *state, uint8_t row, uint8_t *pixels)
{
    const uint16_t row_address = apple2_text_row_address(state->page2, row);
    for (uint8_t column = 0; column < 40U; ++column) {
        bool inverse = false;
        const uint8_t code = memory[(uint16_t)(row_address + column)];
        const bool flashing = apple2_text_code_is_flashing(code);
        const uint8_t ascii = apple2_text_code_to_ascii(code, &inverse);
        const uint8_t *glyph = apple2_ascii_font(ascii);
        const bool cell_inverse = inverse || (flashing && state->flash_state);
        for (uint8_t py = 0; py < 8U; ++py) {
            const uint8_t row_bits = glyph[py];
            uint8_t *dst = pixels + (size_t)(row * 8U + py) * APPLE2_VIDEO_WIDTH + (size_t)column * 7U;
            for (uint8_t px = 0; px < 7U; ++px) {
                const bool bit = (row_bits & (uint8_t)(1U << (6U - px))) != 0U;
                dst[px] = (uint8_t)((bit ^ cell_inverse) ? APPLE2_COLOR_WHITE : APPLE2_COLOR_BLACK);
            }
        }
    }
}

static void apple2_render_lores_row(const uint8_t *memory, const apple2_video_state_t *state, uint8_t row, uint8_t *pixels)
{
    const uint16_t row_address = apple2_text_row_address(state->page2, row);
    for (uint8_t column = 0; column < 40U; ++column) {
        const uint8_t cell = memory[(uint16_t)(row_address + column)];
        const uint8_t top = (uint8_t)(cell & 0x0FU);
        const uint8_t bottom = (uint8_t)(cell >> 4);
        for (uint8_t py = 0; py < 8U; ++py) {
            const uint8_t color = py < 4U ? top : bottom;
            uint8_t *dst = pixels + (size_t)(row * 8U + py) * APPLE2_VIDEO_WIDTH + (size_t)column * 7U;
            memset(dst, color, 7U);
        }
    }
}

static void apple2_render_hires(const uint8_t *memory, const apple2_video_state_t *state, uint8_t *pixels)
{
    uint8_t mono[APPLE2_VIDEO_WIDTH];
    uint8_t phase[APPLE2_VIDEO_WIDTH];

    for (uint16_t line = 0; line < APPLE2_VIDEO_HEIGHT; ++line) {
        memset(mono, 0, sizeof(mono));
        memset(phase, 0, sizeof(phase));

        const uint16_t base = apple2_hires_line_address(state->page2, (uint8_t)line);
        for (uint8_t byte_index = 0; byte_index < 40U; ++byte_index) {
            const uint8_t value = memory[(uint16_t)(base + byte_index)];
            const uint8_t shift = (uint8_t)(value >> 7);
            for (uint8_t bit = 0; bit < 7U; ++bit) {
                const uint16_t x = (uint16_t)(byte_index * 7U + bit);
                mono[x] = (uint8_t)((value >> bit) & 0x01U);
                phase[x] = shift;
            }
        }

        uint8_t *dst = pixels + (size_t)line * APPLE2_VIDEO_WIDTH;
        for (uint16_t x = 0; x < APPLE2_VIDEO_WIDTH; ++x) {
            if (!mono[x]) {
                dst[x] = APPLE2_COLOR_BLACK;
                continue;
            }

            const bool left = x > 0U && mono[x - 1U] != 0U;
            const bool right = x + 1U < APPLE2_VIDEO_WIDTH && mono[x + 1U] != 0U;
            if (left || right) {
                dst[x] = APPLE2_COLOR_WHITE;
                continue;
            }

            const bool shifted = phase[x] != 0U;
            const bool odd = (x & 1U) != 0U;
            if (shifted) {
                dst[x] = odd ? APPLE2_COLOR_MEDIUM_BLUE : APPLE2_COLOR_ORANGE;
            } else {
                dst[x] = odd ? APPLE2_COLOR_VIOLET : APPLE2_COLOR_GREEN;
            }
        }
    }
}

void apple2_video_render(const uint8_t *memory, const apple2_video_state_t *state, uint8_t *pixels)
{
    if (!state->text_mode && state->hires_mode) {
        apple2_render_hires(memory, state, pixels);
        if (state->mixed_mode) {
            for (uint8_t row = 20U; row < 24U; ++row) {
                apple2_render_text_row(memory, state, row, pixels);
            }
        }
        return;
    }

    for (uint8_t row = 0; row < 24U; ++row) {
        if (!state->text_mode && !state->hires_mode && !(state->mixed_mode && row >= 20U)) {
            apple2_render_lores_row(memory, state, row, pixels);
        } else {
            apple2_render_text_row(memory, state, row, pixels);
        }
    }
}
